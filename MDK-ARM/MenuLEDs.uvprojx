# Keil uVision project MenuLEDs.uvprojx, settings and files
target MiniDK2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MenuLEDs
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DBG_ITM
  c include: ..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport;..\Libraries\GLCD;..\Libraries\TouchPanel;..\USER;..\Libraries\LPC1700CMSIS_Firmware_Library\include;..\Libraries\LEDs;..\Libraries\SD_FILE;..\Libraries\SERIAL;..\Libraries\SPI;..\Libraries\TCP_CM3;..\Web
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ../Libraries/CM3/DeviceSupport/: startup_LPC17xx.s system_LPC17xx.c
    ../Libraries/CM3/CoreSupport/: core_cm3.c
  group User
    ../USER/: main.c HTTP_CGI.c
  group CMSIS
    ../Libraries/LPC1700CMSIS_Firmware_Library/source/: lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_ssp.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c
  group Net_Files
    ../USER/: Net_Config.c Net_Debug.c
    ../Libraries/TCP_CM3/: EMAC_LPC17xx_LAN8720.c TCP_CM3.lib TCPD_CM3.lib
  group Readme
    ../: readme.txt
  group WebData
    ../Web/: Web.inp web.c index.cgi
  group Uart
    ../../TP_Simple_v4_KEIL4 6 hilos_Nueva1-7/MDK-ARM/: uart.c
  group TouchPanel
    ../../TP_Simple_v4_KEIL4 6 hilos_Nueva1-7/Libraries/TouchPanel/: TouchPanel.c
  group GLCD
    ../../TP_Simple_v4_KEIL4 6 hilos_Nueva1-7/Libraries/GLCD/: GLCD.c AsciiLib.c
  group I2C
    ../../jmra_test_I2C_NUNCHUCK/: i2c_lpc17xx.c
software components: CMSIS:CORE 5.6.0
